# Keil uVision project code.uvprojx, settings and files
target code (6160000::V6.16::ARMCLANG)
  device: -AT32F413CCU7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: code +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=6 wLevel=3
  c define: AT32F413CCU7,USE_STDPERIPH_DRIVER,AT_START_F413_V1,AT32
  c include: .\inc;.\libraries\drivers\inc;.\libraries\cmsis\cm4\device_support;.\libraries\cmsis\cm4\core_support;.\libraries\i2c_application_library;.\app;.\freertos\include;.\freertos\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group freertos
    ./FreeRTOS-Kernel/: list.c tasks.c
    ./FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c
    ./FreeRTOS-Kernel/portable/MemMang/: heap_4.c
  group user
    ./src/: at32f413_clock.c at32f413_int.c main.c
  group firmware
    ./libraries/cmsis/cm4/device_support/: system_at32f413.c
    ./libraries/drivers/src/: at32f413_misc.c at32f413_gpio.c at32f413_crm.c at32f413_usart.c at32f413_pwc.c at32f413_i2c.c at32f413_dma.c
  group cmsis
    ./libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f413.s
  group readme
    ./: README.md
  group library
    ./libraries/i2c_application_library/: i2c_application.c
  group app
    ./app/: buzzer.c ec11.c gpio_init.c hot_plate.c led.c ptc.c ssd1306.c xtp_defines.c
